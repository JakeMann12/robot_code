Commit message: fixed simple_rexy_env, allegedly

File: URDFs/feetasrigidjts/jake.urdf (robot description, URDF)
Before this commit: robot jake, 26 links, 25 joints
Links:
- removed link Noggin_v21
Joints:
- removed joint Rigid_25
